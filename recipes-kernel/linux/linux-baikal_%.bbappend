
inherit tpsdksrc

TPSDK_SUBDIR = "kernel"
