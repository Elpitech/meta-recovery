
DEPENDS_remove = "libffi"

EXTRA_OEMAKE += "MICROPY_PY_FFI=0"
