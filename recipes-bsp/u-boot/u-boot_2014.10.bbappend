EXTRA_OEMAKE_append = " VERSION_APPEND=' / Yocto ${DISTRO} ${DISTRO_VERSION}'"
