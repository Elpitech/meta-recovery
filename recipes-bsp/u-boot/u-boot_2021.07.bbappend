#EXTRA_OEMAKE:append = " VERSION_APPEND=' / Yocto ${DISTRO} ${DISTRO_VERSION}'"
