
inherit tpsdksrc

TPSDK_SUBDIR = "u-boot"
