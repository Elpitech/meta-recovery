
ALTERNATIVE_LINK_NAME[rx] = "${bindir}/rx"

